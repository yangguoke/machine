# Keil uVision project machine.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: machine +hex
  c flags: Optimize=8 SizeSpeed=1
  group App
    ../App/: main.c
  group Timer
    ../Timer/: timer.c
  group Uart
    ../Uart/: uart.c
  group Key
    ../Key/: simplekey.c
